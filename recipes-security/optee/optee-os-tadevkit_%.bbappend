optee-os_%.bbappend