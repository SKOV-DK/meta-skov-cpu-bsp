COMPATIBLE_MACHINE:imx8-cpu = "imx8-cpu"
COMPATIBLE_MACHINE:imx6-cpu = "imx6-cpu"
