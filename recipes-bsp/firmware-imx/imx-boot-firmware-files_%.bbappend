COMPATIBLE_MACHINE = "imx8-cpu|imx8s-cpu"
