COMPATIBLE_MACHINE:imx8eval = "imx8eval"
COMPATIBLE_MACHINE:imx8-cpu = "imx8-cpu"
