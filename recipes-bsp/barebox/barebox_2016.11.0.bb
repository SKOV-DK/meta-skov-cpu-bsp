require barebox-skov.inc

SRC_URI[md5sum] = "53a04c58562e2aba874b5a1079146eba"
SRC_URI[sha256sum] = "9a670ab785738ce4ef7a15bcac2522564dc3af1c49064440f3fd31d0e7a342db"
