require at91bootstrap.inc

SRC_URI[tarball.md5sum] = "bdeb91566f44702dd5a9b73d5a4ebd25"
