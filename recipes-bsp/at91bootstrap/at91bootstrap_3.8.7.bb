require at91bootstrap.inc

SRC_URI[tarball.md5sum] = "f3ee628346dfde19c622ea1291194cda"
SRC_URI[tarball.sha256sum] = "ab76cc7b19ffda6d55fb7dac1b05feebec0e336c5dcdfb15a2a71897a4bf9387"

